options:
  parameters:
    author: Piotr Krysik
    category: Custom
    description: 'Interactive monitor of a single C0 channel with analysis performed by Wireshark (command to run wireshark: sudo wireshark -k -f udp -Y gsmtap -i lo)'
    generate_options: qt_gui
    id: grgsm_livemon
    output_language: python
    title: Gr-gsm Livemon
  states: {}

blocks:
- name: fc_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '100'
    start: 800e6
    step: 2e5
    stop: 1990e6
    value: fc
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: Gain
    min_len: '100'
    start: '0'
    step: '0.5'
    stop: '100'
    value: gain
    widget: counter
  states: {}
- name: ppm_slider
  id: variable_qtgui_range
  parameters:
    label: PPM Offset
    min_len: '100'
    start: '-150'
    step: '0.1'
    stop: '150'
    value: ppm
    widget: counter
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Arguments
    type: str
    value: '""'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: serverport
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_1
  id: blocks_socket_pdu
  parameters:
    host: collector
    mtu: '1500'
    port: collectorport
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: collector
  id: parameter
  parameters:
    label: IP or DNS name of collector point
    type: str
    value: '"localhost"'
  states: {}
- name: collectorport
  id: parameter
  parameters:
    label: UDP port number of collector
    type: str
    value: '4729'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: GSM channel's central frequency
    short_id: f
    type: eng_float
    value: 941.8e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: eng_float
    value: '30'
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc_slider-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: fc_slider-shiftoff
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'True'
    prepend_frame_count: 'True'
    prepend_string: '""'
    print_gsmtap_header: 'True'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[arfcn.downlink2arfcn(fc)]'
    osr: osr
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(250e3+abs(shiftoff))
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(fc_slider-shiftoff)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import gnuradio.gsm.arfcn as arfcn
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: serverport
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: collectorport
    type: UDP_CLIENT
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OverSampling Ratio
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc_slider
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: 250e3+abs(shiftoff)
    corr0: ppm_slider
    dc_offset_mode0: '2'
    freq0: fc_slider-shiftoff
    gain0: gain_slider
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: '2000000.052982'
  states: {}
- name: serverport
  id: parameter
  parameters:
    label: UDP server listening port
    type: str
    value: '4729'
  states: {}
- name: shiftoff
  id: parameter
  parameters:
    label: Frequency Shiftoff
    short_id: o
    type: eng_float
    value: 400e3
  states: {}

connections:
- [blocks_rotator_cc_0, '0', gsm_input_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_socket_pdu_0_0, pdus, gsm_message_printer_1, msgs]
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, blocks_socket_pdu_0_1, pdus]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0, pdus]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_0_0, pdus]
- [gsm_control_channels_decoder_0_0, msgs, blocks_socket_pdu_0_1, pdus]
- [gsm_control_channels_decoder_0_0, msgs, network_socket_pdu_0_0, pdus]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [iio_pluto_source_0, '0', blocks_rotator_cc_0, '0']
- [network_socket_pdu_0, pdus, gsm_message_printer_1, msgs]

metadata:
  file_format: 1
